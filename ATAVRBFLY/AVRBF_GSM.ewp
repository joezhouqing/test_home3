# IAR project AVRBF_GSM.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm169.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group ATAVRBF
    ATAVRBFLY_FILES/: BCD.c button.c LCD_driver.c LCD_functions.c main.c STATE_functions.c
  group AVRGSM
    AVRGSM_FILES/: AVRGSM_api.c AVRGSM_com.c AVRGSM_tools.c AVRGSM_zip.c
